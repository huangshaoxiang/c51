# Keil uVision project 51_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51_project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver\inc
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./driver/src/: led.c
